FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Add u-boot-aspeed patches here
SRC_URI_append = " \
       "