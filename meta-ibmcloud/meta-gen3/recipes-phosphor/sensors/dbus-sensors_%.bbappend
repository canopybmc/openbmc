PACKAGECONFIG_gen3 = "hwmontempsensor"