FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"

SRC_URI:append = " file://tiogapass.cfg "
